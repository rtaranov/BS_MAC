# IAR project Backup of txrx_simple.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.newCCIncludePaths: ..\drivers\bsp; ..\drivers\bsp\drivers; ..\drivers\bsp\boards\EZ430RF; ..\drivers\mrfi
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Application
    ../c_files/: txrx_simple.c txrx_simple.h
  group Components/Board
    ../c_files/: board.c board.h
  group Components/bsp
    ../drivers/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/I2C
    ../c_files/: I2C.c I2C.h
  group Components/mrfi
    ../drivers/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/Sensors
    ../c_files/: Sensors.c Sensors.h
  group Components/StringFukc
    ../c_files/: stringFun.c stringFun.h
